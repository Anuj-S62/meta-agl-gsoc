require recipes-platform/images/agl-ivi-demo-platform.bb

IMAGE_INSTALL:append = "flutter-gsoc"